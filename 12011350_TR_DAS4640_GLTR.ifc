Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-04-25T14:59:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Apr 25 14:59:58 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\74cb77a7-f4aa-412f-944e-32ab495c7590\dd53bf39-ce19-4e3f-98bb-f90775e5683f\ifc * Database version: 5507 * Database creation date: Mon Apr 25 14:59:58 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Apr 25 14:59:58 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Apr 25 14:59:58 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12011350_TR_DAS4640_GLTR:28S4640T_TR_12011350_DAS4640_GLTR, (2)
In: Default
Type - Material: Výchozí Nový materiál
Type - Pset_BuildingElementProxyCommon - Reference: 28S4640T_TR_12011350_DAS4640_GLTR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 28S4640T_TR_12011350_DAS4640_GLTR
Material: Výchozí Nový materiál, z_Miele_Design_CLST, Plast, z_Miele_Connection_Electric, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 561 mm; Height: 335 mm; Depth: 307 mm

# IfcDistributionPort, Port_350511
Description: Flow; FlowDirection: SOURCEANDSINK
